# Keil uVision project car_ctr.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F340 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: car_ctr +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c LC1602.c LC12864.c DS18B20.c
